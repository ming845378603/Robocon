# Keil uVision project USART.uvprojx, settings and files
target USART (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\FWLIB\inc;..\HARDWARE\GYRO;..\HARDWARE\Motor_Drive;..\APP\Control\Basic_Move_Ctrl;..\HARDWARE\CAN;..\SYSTEM;..\APP\Math\Vect;..\APP\Math;..\..\2018underpan;..\APP\Control\PID;..\APP\Robot;..\HARDWARE\FLASH;..\HARDWARE\ANO_DT;..\HARDWARE\UART;..\HARDWARE\OLED;..\HARDWARE\ENCODER;..\APP\Control\Basic_Move_Ctrl;..\APP\Control\PID;..\APP\Control;..\APP\Control;..\HARDWARE\Task_Loop;..\HARDWARE\SysTick;..\HARDWARE\Time;..\HARDWARE\Timer;..\HARDWARE\Laser_Ranging;..\HARDWARE\Communication;..\HARDWARE\Queue;..\HARDWARE\Support;..\APP;..\NewRoute;..\HARDWARE\ELMO_Driver;..\HARDWARE\ANO_DT;..\HARDWARE\ENCODER;..\HARDWARE\GYRO;..\UP\RELAY;..\UP\RMDS;..\UP\SWITCH;..\UP\STEPPER;..\HARDWARE\ELMO;..\APP\Control_Arc;..\APP\task
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/Time/: Time.c
    ../HARDWARE/SysTick/: SysTick.c
    ../HARDWARE/Timer/: Timer_3.c Timer_6.c Timer_7.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/UART/: usart2.c usart3.c uart4.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/Motor_Drive/: epos_N.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/GYRO/: GYRO_Driver.c
    ../HARDWARE/FLASH/: stmflash.c
    ../HARDWARE/ANO_DT/: ANO_DT.c
    ../APP/Math/: My_Math.c
    ../: My_BSP.c
    ../HARDWARE/ELMO/: elmo_drive.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c
  group README
    ../: readme.txt
  group APP
    ../APP/Control/PID/: PID_Control.c PID_Parameter.c PID_forward.c
    ../APP/Robot/: Robot.c
    ../APP/task/: task.c
    ../APP/Control_Arc/: Control_Arc.c
  group Route
    ../APP/Control/Basic_Move_Ctrl/: Route_Control.c Basal_Move.c
  group UP
    ../UP/RELAY/: relay.c
    ../UP/RMDS/: rmds.c
    ../UP/SWITCH/: switch.c
    ../UP/STEPPER/: Stepper.c
